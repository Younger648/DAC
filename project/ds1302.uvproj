# Keil uVision project ds1302.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: ds1302 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\sourse
  group main
    ../sourse/: main.c
  group c
    ../sourse/: head.c onewire.c ds1302.c iic.c ds18b20.c timer.c HC138.c SMG.c ds1302config.c key.c menu.c led.c jidianqi.c DAC_config.c
  group h
    ../sourse/: head.h config.h onewire.h ds1302.h iic.h ds18b20.h timer.h HC138.h SMG.h ds1302config.h menu.h key.h led.h jidianqi.h DAC_config.h
